Commit message: graspchecker works with apple (see readme for example) - grasp mode works with physical lifting (only apple)

File: ycb/apple.urdf (robot description, URDF)
Before this commit: robot 00_apple_red, 1 links, 0 joints
Links:
- link base_link: mass 30.0 -> 0.1
