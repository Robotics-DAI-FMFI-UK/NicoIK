Commit message: grasping class - WIP

File: nico_graspfixed.urdf (robot description, URDF)
Before this commit: robot nico_upper_rh6d, 27 links, 26 joints
Joints:
- joint r_indexfinger_x: type revolute -> fixed
